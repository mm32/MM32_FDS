<?xml version="1.0"?>
<ProjectWorkspace xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:noNamespaceSchemaLocation="project_mpw.xsd">
	<SchemaVersion>1.0</SchemaVersion>
	<Header>### uVision Project, (C) Keil Software</Header>
	<WorkspaceName>rcc</WorkspaceName>
	<project>
		<PathAndName>.\project\rcc\rcc_mco.uvprojx</PathAndName>
		<NodeIsActive>1</NodeIsActive>
	</project>
</ProjectWorkspace>
