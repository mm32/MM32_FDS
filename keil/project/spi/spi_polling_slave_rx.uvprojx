# Keil uVision project spi_polling_slave_rx.uvprojx, settings and files
target MM32L373 (ARM-ADS)
  device: MM32L373PF MindMotion
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(8000000) ELITTLE
  output: spi_polling_slave_rx +hex
  c flags: Optim=1 uC99=1
  c define: __KEIL __MM3N1 __EX_SPI __MM32_MINIBOARD OVERTIME=0 _USER_RESOURCE _SYS_RESOURCE_IT __SYS_RESOURCE_POLLING
  c include: ..\..\bsp\inc;..\..\driver\inc;..\..\..\library\HAL_lib\inc;..\..\..\library\startup\inc;..\..\app\spi\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: ..\_config\MM32f103xB.sct
  group app
    ../../app/spi/: spi_polling_slave_rx.c
  group bsp
    ../../bsp/: bsp.c bsp_adc.c bsp_can.c bsp_comp.c bsp_crs.c bsp_dac.c bsp_i2c.c bsp_key.c bsp_led.c bsp_mco.c bsp_opamp.c bsp_spi.c bsp_tim.c bsp_uart.c
  group driver
    ../../driver/: common.c drv.c drv_adc.c drv_aes.c drv_bkp.c drv_can.c drv_comp.c drv_crc.c drv_crs.c drv_dac.c drv_display.c drv_div.c drv_dma.c drv_eeprom.c drv_exti.c drv_gpio.c drv_i2c.c drv_iwdg.c drv_keyboard.c drv_mco.c drv_opamp.c drv_power.c drv_protect.c drv_rtc.c drv_spi.c drv_sqrt.c drv_tim.c drv_uart.c drv_wwdg.c
  group lib
    ../../../library/HAL_lib/: HAL_adc.c HAL_aes.c HAL_bkp.c HAL_can.c HAL_comp.c HAL_crc.c HAL_crs.c HAL_dac.c HAL_dbg.c HAL_div.c HAL_dma.c HAL_exti.c HAL_flash.c HAL_gpio.c HAL_i2c.c HAL_iwdg.c HAL_nvic.c HAL_opamp.c HAL_pwr.c HAL_rcc.c HAL_rtc.c HAL_spi.c HAL_sqrt.c HAL_tim.c HAL_uart.c HAL_uid.c HAL_wwdg.c
  group system
    ../../../library/startup/: resource.c startup_mm32.c system_mm32.c
target MM32L073 (ARM-ADS)
  device: MM32L073PF MindMotion
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(8000000) ELITTLE
  output: spi_polling_slave_rx +hex
  c flags: Optim=1 uC99=1
  c define: __KEIL __MM0N1 __EX_SPI __MM32_MINIBOARD OVERTIME=0 _USER_RESOURCE _SYS_RESOURCE_IT __SYS_RESOURCE_POLLING
  c include: ..\..\bsp\inc;..\..\driver\inc;..\..\app\spi\inc;..\..\..\library\HAL_lib\inc;..\..\..\library\startup\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: ..\_config\MM32F031x8.sct
target MM32SPIN27 (ARM-ADS)
  device: MM32SPIN27PF MindMotion
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(8000000) ELITTLE
  output: spi_polling_slave_rx +hex
  c flags: Optim=1 uC99=1
  c define: __KEIL __MM0P1 __EX_SPI __MM32_MINIBOARD OVERTIME=0 _USER_RESOURCE _SYS_RESOURCE_IT __SYS_RESOURCE_POLLING
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: ..\_config\MM32SPIN27.sct
target MM32F031 (ARM-ADS)
  device: MM32F031C6T MindMotion
  cpu: IROM(0x08000000,0x8000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0") CLOCK(8000000) ELITTLE
  output: spi_polling_slave_rx +hex
  c flags: Optim=1 uC99=1
  c define: __KEIL __MM0Q1 __EX_SPI __MM32_MINIBOARD OVERTIME=0 _USER_RESOURCE _SYS_RESOURCE_IT __SYS_RESOURCE_POLLING
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  scatter file: ..\_config\mm32f031x6.sct
software components: CMSIS:CORE 5.1.2
