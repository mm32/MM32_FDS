<?xml version="1.0"?>
<workspace>
	<project>
		<path>$WS_DIR$\project\spi\spi_dma_master_rx.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\project\spi\spi_dma_master_tx.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\project\spi\spi_dma_slave_rx.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\project\spi\spi_dma_slave_tx.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\project\spi\spi_it_master_rx.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\project\spi\spi_it_master_tx.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\project\spi\spi_it_slave_rx.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\project\spi\spi_it_slave_tx.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\project\spi\spi_polling_master_rx.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\project\spi\spi_polling_master_tx.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\project\spi\spi_polling_slave_rx.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\project\spi\spi_polling_slave_tx.ewp</path>
	</project>
	<batchBuild>
		<batchDefinition>
			<name>MM32L373</name>
			<member>
				<project>spi_dma_master_rx</project>
				<configuration>MM32L373</configuration>
			</member>
			<member>
				<project>spi_dma_master_tx</project>
				<configuration>MM32L373</configuration>
			</member>
			<member>
				<project>spi_dma_slave_rx</project>
				<configuration>MM32L373</configuration>
			</member>
			<member>
				<project>spi_dma_slave_tx</project>
				<configuration>MM32L373</configuration>
			</member>
			<member>
				<project>spi_it_master_rx</project>
				<configuration>MM32L373</configuration>
			</member>
			<member>
				<project>spi_it_master_tx</project>
				<configuration>MM32L373</configuration>
			</member>
			<member>
				<project>spi_it_slave_rx</project>
				<configuration>MM32L373</configuration>
			</member>
			<member>
				<project>spi_it_slave_tx</project>
				<configuration>MM32L373</configuration>
			</member>
			<member>
				<project>spi_polling_master_rx</project>
				<configuration>MM32L373</configuration>
			</member>
			<member>
				<project>spi_polling_master_tx</project>
				<configuration>MM32L373</configuration>
			</member>
			<member>
				<project>spi_polling_slave_rx</project>
				<configuration>MM32L373</configuration>
			</member>
			<member>
				<project>spi_polling_slave_tx</project>
				<configuration>MM32L373</configuration>
			</member>
		</batchDefinition>
		<batchDefinition>
			<name>MM32L073</name>
			<member>
				<project>spi_dma_master_rx</project>
				<configuration>MM32L073</configuration>
			</member>
			<member>
				<project>spi_dma_master_tx</project>
				<configuration>MM32L073</configuration>
			</member>
			<member>
				<project>spi_dma_slave_rx</project>
				<configuration>MM32L073</configuration>
			</member>
			<member>
				<project>spi_dma_slave_tx</project>
				<configuration>MM32L073</configuration>
			</member>
			<member>
				<project>spi_it_master_rx</project>
				<configuration>MM32L073</configuration>
			</member>
			<member>
				<project>spi_it_master_tx</project>
				<configuration>MM32L073</configuration>
			</member>
			<member>
				<project>spi_it_slave_rx</project>
				<configuration>MM32L073</configuration>
			</member>
			<member>
				<project>spi_it_slave_tx</project>
				<configuration>MM32L073</configuration>
			</member>
			<member>
				<project>spi_polling_master_rx</project>
				<configuration>MM32L073</configuration>
			</member>
			<member>
				<project>spi_polling_master_tx</project>
				<configuration>MM32L073</configuration>
			</member>
			<member>
				<project>spi_polling_slave_rx</project>
				<configuration>MM32L073</configuration>
			</member>
			<member>
				<project>spi_polling_slave_tx</project>
				<configuration>MM32L073</configuration>
			</member>
		</batchDefinition>
		<batchDefinition>
			<name>MM32SPIN27</name>
			<member>
				<project>spi_dma_master_rx</project>
				<configuration>MM32SPIN27</configuration>
			</member>
			<member>
				<project>spi_dma_master_tx</project>
				<configuration>MM32SPIN27</configuration>
			</member>
			<member>
				<project>spi_dma_slave_rx</project>
				<configuration>MM32SPIN27</configuration>
			</member>
			<member>
				<project>spi_dma_slave_tx</project>
				<configuration>MM32SPIN27</configuration>
			</member>
			<member>
				<project>spi_it_master_rx</project>
				<configuration>MM32SPIN27</configuration>
			</member>
			<member>
				<project>spi_it_master_tx</project>
				<configuration>MM32SPIN27</configuration>
			</member>
			<member>
				<project>spi_it_slave_rx</project>
				<configuration>MM32SPIN27</configuration>
			</member>
			<member>
				<project>spi_it_slave_tx</project>
				<configuration>MM32SPIN27</configuration>
			</member>
			<member>
				<project>spi_polling_master_rx</project>
				<configuration>MM32SPIN27</configuration>
			</member>
			<member>
				<project>spi_polling_master_tx</project>
				<configuration>MM32SPIN27</configuration>
			</member>
			<member>
				<project>spi_polling_slave_rx</project>
				<configuration>MM32SPIN27</configuration>
			</member>
			<member>
				<project>spi_polling_slave_tx</project>
				<configuration>MM32SPIN27</configuration>
			</member>
		</batchDefinition>
	</batchBuild>
</workspace>
