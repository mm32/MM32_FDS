<?xml version="1.0"?>
<workspace>
	<project>
		<path>$WS_DIR$\project\gpio\gpio.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\project\gpio\key_led.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\project\gpio\key_led_async.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\project\gpio\key_led_sync.ewp</path>
	</project>
	<batchBuild>
		<batchDefinition>
			<name>MM32L373</name>
			<member>
				<project>gpio</project>
				<configuration>MM32L373</configuration>
			</member>
			<member>
				<project>key_led</project>
				<configuration>MM32L373</configuration>
			</member>
			<member>
				<project>key_led_async</project>
				<configuration>MM32L373</configuration>
			</member>
			<member>
				<project>key_led_sync</project>
				<configuration>MM32L373</configuration>
			</member>
		</batchDefinition>
		<batchDefinition>
			<name>MM32L073</name>
			<member>
				<project>gpio</project>
				<configuration>MM32L073</configuration>
			</member>
			<member>
				<project>key_led</project>
				<configuration>MM32L073</configuration>
			</member>
			<member>
				<project>key_led_async</project>
				<configuration>MM32L073</configuration>
			</member>
			<member>
				<project>key_led_sync</project>
				<configuration>MM32L073</configuration>
			</member>
		</batchDefinition>
	</batchBuild>
</workspace>
