<?xml version="1.0"?>
<workspace>
	<project>
		<path>$WS_DIR$\project\tim\tim_6step.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\project\tim\tim_onepulse.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\project\tim\tim_encoder.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\project\tim\tim_pwm_it.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\project\tim\tim_pwm_dma.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\project\tim\tim_capture_pulse.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\project\tim\tim_capture_pwm.ewp</path>
	</project>
	<batchBuild>
		<batchDefinition>
			<name>MM32L373</name>
			<member>
				<project>tim_6step</project>
				<configuration>MM32L373</configuration>
			</member>
			<member>
				<project>tim_onepulse</project>
				<configuration>MM32L373</configuration>
			</member>
			<member>
				<project>tim_encoder</project>
				<configuration>MM32L373</configuration>
			</member>
			<member>
				<project>tim_pwm_it</project>
				<configuration>MM32L373</configuration>
			</member>
			<member>
				<project>tim_pwm_dma</project>
				<configuration>MM32L373</configuration>
			</member>
			<member>
				<project>tim_capture_pulse</project>
				<configuration>MM32L373</configuration>
			</member>
			<member>
				<project>tim_capture_pwm</project>
				<configuration>MM32L373</configuration>
			</member>
		</batchDefinition>
		<batchDefinition>
			<name>MM32L073</name>
			<member>
				<project>tim_6step</project>
				<configuration>MM32L073</configuration>
			</member>
			<member>
				<project>tim_onepulse</project>
				<configuration>MM32L073</configuration>
			</member>
			<member>
				<project>tim_encoder</project>
				<configuration>MM32L073</configuration>
			</member>
			<member>
				<project>tim_pwm_it</project>
				<configuration>MM32L073</configuration>
			</member>
			<member>
				<project>tim_pwm_dma</project>
				<configuration>MM32L073</configuration>
			</member>
			<member>
				<project>tim_capture_pulse</project>
				<configuration>MM32L073</configuration>
			</member>
			<member>
				<project>tim_capture_pwm</project>
				<configuration>MM32L073</configuration>
			</member>
		</batchDefinition>
		<batchDefinition>
			<name>MM32SPIN27</name>
			<member>
				<project>tim_6step</project>
				<configuration>MM32SPIN27</configuration>
			</member>
			<member>
				<project>tim_onepulse</project>
				<configuration>MM32SPIN27</configuration>
			</member>
			<member>
				<project>tim_encoder</project>
				<configuration>MM32SPIN27</configuration>
			</member>
			<member>
				<project>tim_pwm_it</project>
				<configuration>MM32SPIN27</configuration>
			</member>
			<member>
				<project>tim_pwm_dma</project>
				<configuration>MM32SPIN27</configuration>
			</member>
			<member>
				<project>tim_capture_pulse</project>
				<configuration>MM32SPIN27</configuration>
			</member>
			<member>
				<project>tim_capture_pwm</project>
				<configuration>MM32SPIN27</configuration>
			</member>
		</batchDefinition>
	</batchBuild>
</workspace>
