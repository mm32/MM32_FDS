<?xml version="1.0"?>
<workspace>
	<project>
		<path>$WS_DIR$\project\rtc\rtc.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\project\rtc\rtc_tamper.ewp</path>
	</project>
	<batchBuild>
		<batchDefinition>
			<name>MM32L373</name>
			<member>
				<project>rtc</project>
				<configuration>MM32L373</configuration>
			</member>
			<member>
				<project>rtc_tamper</project>
				<configuration>MM32L373</configuration>
			</member>
		</batchDefinition>
	</batchBuild>
</workspace>
