<?xml version="1.0"?>
<workspace>
	<project>
		<path>$WS_DIR$\project\dac\dac.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\project\dac\dac_dual_tim.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\project\dac\dac_tranglewave.ewp</path>
	</project>
	<batchBuild>
		<batchDefinition>
			<name>MM32L373</name>
			<member>
				<project>dac</project>
				<configuration>MM32L373</configuration>
			</member>
			<member>
				<project>dac_dual_tim</project>
				<configuration>MM32L373</configuration>
			</member>
			<member>
				<project>dac_tranglewave</project>
				<configuration>MM32L373</configuration>
			</member>
		</batchDefinition>
	</batchBuild>
</workspace>
