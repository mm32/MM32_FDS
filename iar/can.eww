<?xml version="1.0"?>
<workspace>
	<project>
		<path>$WS_DIR$\project\can\can.ewp</path>
	</project>
</workspace>
