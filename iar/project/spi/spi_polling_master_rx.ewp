# IAR project spi_polling_master_rx.ewp, settings and files
configuration MM32L373 (ARM, debug)
  General.OGChipSelectEditMenu: MM32L373PF MindMotion MM32L373PF
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: __IAR; __MM3N1; __EX_SPI; __MM32_MINIBOARD; OVERTIME=0; CLOCK=8000000; _USER_RESOURCE; _SYS_RESOURCE_IT; __SYS_RESOURCE_POLLING
  ICCARM.CCIncludePath2: ..\..\bsp\inc; ..\..\driver\inc; ..\..\..\library\HAL_lib\inc; ..\..\..\library\startup\inc; ..\..\app\spi\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: MM3N1
  OBJCOPY.OOCOutputFile: spi_polling_master_rx.hex
  ILINK.IlinkOutputFile: spi_polling_master_rx.out
  ILINK.IlinkIcfFile: ..\_config\MM32f103xB.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration MM32L073 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MM32L073PF MindMotion MM32L073PF
  General.CoreVariant: 34
  ICCARM.CCDefines: __IAR; __MM0N1; __EX_SPI; __MM32_MINIBOARD; OVERTIME=0; CLOCK=8000000; _USER_RESOURCE; _SYS_RESOURCE_IT; __SYS_RESOURCE_POLLING
  ICCARM.CCIncludePath2: ..\..\bsp\inc; ..\..\driver\inc; ..\..\app\spi\inc; ..\..\..\library\HAL_lib\inc; ..\..\..\library\startup\inc
  AARM.ADefines: MM0N1
  ILINK.IlinkIcfFile: ..\_config\MM32F031x8.icf
configuration MM32SPIN27 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MM32SPIN27PF MindMotion MM32SPIN27PF
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 34
  ICCARM.CCDefines: __IAR; __MM0P1; __EX_SPI; __MM32_MINIBOARD; OVERTIME=0; CLOCK=8000000; _USER_RESOURCE; _SYS_RESOURCE_IT; __SYS_RESOURCE_POLLING
  ICCARM.CCIncludePath2: as above
  AARM.ADefines: MM0P1
  ILINK.IlinkIcfFile: ..\_config\MM32SPIN27.icf
configuration MM32F031 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MM32F031C6T MindMotion MM32F031C6T
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 34
  ICCARM.CCDefines: __IAR; __MM0Q1; __EX_SPI; __MM32_MINIBOARD; OVERTIME=0; CLOCK=8000000; _USER_RESOURCE; _SYS_RESOURCE_IT; __SYS_RESOURCE_POLLING
  ICCARM.CCIncludePath2: as above
  AARM.ADefines: MM0Q1
  ILINK.IlinkIcfFile: ..\_config\mm32f031x6.icf
  group app
    ../../app/spi/: spi_polling_master_rx.c
  group bsp
    ../../bsp/: bsp.c bsp_adc.c bsp_can.c bsp_comp.c bsp_crs.c bsp_dac.c bsp_i2c.c bsp_key.c bsp_led.c bsp_mco.c bsp_opamp.c bsp_spi.c bsp_tim.c bsp_uart.c
  group driver
    ../../driver/: common.c drv.c drv_adc.c drv_aes.c drv_bkp.c drv_can.c drv_comp.c drv_crc.c drv_crs.c drv_dac.c drv_display.c drv_div.c drv_dma.c drv_eeprom.c drv_exti.c drv_gpio.c drv_i2c.c drv_iwdg.c drv_keyboard.c drv_mco.c drv_opamp.c drv_power.c drv_protect.c drv_rtc.c drv_spi.c drv_sqrt.c drv_tim.c drv_uart.c drv_wwdg.c
  group lib
    ../../../library/HAL_lib/: HAL_adc.c HAL_aes.c HAL_bkp.c HAL_can.c HAL_comp.c HAL_crc.c HAL_crs.c HAL_dac.c HAL_dbg.c HAL_div.c HAL_dma.c HAL_exti.c HAL_flash.c HAL_gpio.c HAL_i2c.c HAL_iwdg.c HAL_nvic.c HAL_opamp.c HAL_pwr.c HAL_rcc.c HAL_rtc.c HAL_spi.c HAL_sqrt.c HAL_tim.c HAL_uart.c HAL_uid.c HAL_wwdg.c
  group system
    ../../../library/startup/: resource.c startup_mm32.c system_mm32.c
