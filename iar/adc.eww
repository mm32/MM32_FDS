<?xml version="1.0"?>
<workspace>
	<project>
		<path>$WS_DIR$\project\adc\adc_continue_dma_async.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\project\adc\adc_continue_dma_sync.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\project\adc\adc_imm_dma.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\project\adc\adc_imm_it.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\project\adc\adc_imm_polling.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\project\adc\adc_scan_dma.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\project\adc\adc_window_comp.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\project\adc\adc_testTemp.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\project\adc\m_imm_it_exti.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\project\adc\m_scan_dma_time.ewp</path>
	</project>
	<batchBuild>
		<batchDefinition>
			<name>MM32L373</name>
			<member>
				<project>adc_continue_dma_async</project>
				<configuration>MM32L373</configuration>
			</member>
			<member>
				<project>adc_continue_dma_sync</project>
				<configuration>MM32L373</configuration>
			</member>
			<member>
				<project>adc_imm_dma</project>
				<configuration>MM32L373</configuration>
			</member>
			<member>
				<project>adc_imm_it</project>
				<configuration>MM32L373</configuration>
			</member>
			<member>
				<project>adc_imm_polling</project>
				<configuration>MM32L373</configuration>
			</member>
			<member>
				<project>adc_scan_dma</project>
				<configuration>MM32L373</configuration>
			</member>
			<member>
				<project>adc_window_comp</project>
				<configuration>MM32L373</configuration>
			</member>
			<member>
				<project>adc_testTemp</project>
				<configuration>MM32L373</configuration>
			</member>
			<member>
				<project>m_imm_it_exti</project>
				<configuration>MM32L373</configuration>
			</member>
			<member>
				<project>m_scan_dma_time</project>
				<configuration>MM32L373</configuration>
			</member>
		</batchDefinition>
		<batchDefinition>
			<name>MM32L073</name>
			<member>
				<project>adc_continue_dma_async</project>
				<configuration>MM32L073</configuration>
			</member>
			<member>
				<project>adc_continue_dma_sync</project>
				<configuration>MM32L073</configuration>
			</member>
			<member>
				<project>adc_imm_dma</project>
				<configuration>MM32L073</configuration>
			</member>
			<member>
				<project>adc_imm_it</project>
				<configuration>MM32L073</configuration>
			</member>
			<member>
				<project>adc_imm_polling</project>
				<configuration>MM32L073</configuration>
			</member>
			<member>
				<project>adc_scan_dma</project>
				<configuration>MM32L073</configuration>
			</member>
			<member>
				<project>adc_window_comp</project>
				<configuration>MM32L073</configuration>
			</member>
			<member>
				<project>adc_testTemp</project>
				<configuration>MM32L073</configuration>
			</member>
			<member>
				<project>m_imm_it_exti</project>
				<configuration>MM32L073</configuration>
			</member>
			<member>
				<project>m_scan_dma_time</project>
				<configuration>MM32L073</configuration>
			</member>
		</batchDefinition>
		<batchDefinition>
			<name>MM32SPIN27</name>
			<member>
				<project>adc_continue_dma_async</project>
				<configuration>MM32SPIN27</configuration>
			</member>
			<member>
				<project>adc_continue_dma_sync</project>
				<configuration>MM32SPIN27</configuration>
			</member>
			<member>
				<project>adc_imm_dma</project>
				<configuration>MM32SPIN27</configuration>
			</member>
			<member>
				<project>adc_imm_it</project>
				<configuration>MM32SPIN27</configuration>
			</member>
			<member>
				<project>adc_imm_polling</project>
				<configuration>MM32SPIN27</configuration>
			</member>
			<member>
				<project>adc_scan_dma</project>
				<configuration>MM32SPIN27</configuration>
			</member>
			<member>
				<project>adc_window_comp</project>
				<configuration>MM32SPIN27</configuration>
			</member>
			<member>
				<project>adc_testTemp</project>
				<configuration>MM32SPIN27</configuration>
			</member>
			<member>
				<project>m_imm_it_exti</project>
				<configuration>MM32SPIN27</configuration>
			</member>
			<member>
				<project>m_scan_dma_time</project>
				<configuration>MM32SPIN27</configuration>
			</member>
		</batchDefinition>
	</batchBuild>
</workspace>
