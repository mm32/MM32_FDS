<?xml version="1.0"?>
<workspace>
	<project>
		<path>$WS_DIR$\project\exti\exti_key.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\project\exti\exti_decode.ewp</path>
	</project>
	<batchBuild>
		<batchDefinition>
			<name>MM32L373</name>
			<member>
				<project>exti_key</project>
				<configuration>MM32L373</configuration>
			</member>
			<member>
				<project>exti_decode</project>
				<configuration>MM32L373</configuration>
			</member>
		</batchDefinition>
		<batchDefinition>
			<name>MM32L073</name>
			<member>
				<project>exti_key</project>
				<configuration>MM32L073</configuration>
			</member>
			<member>
				<project>exti_decode</project>
				<configuration>MM32L073</configuration>
			</member>
		</batchDefinition>
		<batchDefinition>
			<name>MM32SPIN27</name>
			<member>
				<project>exti_key</project>
				<configuration>MM32SPIN27</configuration>
			</member>
			<member>
				<project>exti_decode</project>
				<configuration>MM32SPIN27</configuration>
			</member>
		</batchDefinition>
	</batchBuild>
</workspace>
