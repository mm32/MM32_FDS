<?xml version="1.0"?>
<workspace>
	<project>
		<path>$WS_DIR$\project\opamp\opamp.ewp</path>
	</project>
	<batchBuild>
		<batchDefinition>
			<name>MM32SPIN27</name>
			<member>
				<project>opamp</project>
				<configuration>MM32SPIN27</configuration>
			</member>
		</batchDefinition>
	</batchBuild>
</workspace>
