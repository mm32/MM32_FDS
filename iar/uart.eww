<?xml version="1.0"?>
<workspace>
	<project>
		<path>$WS_DIR$\project\uart\uart_polling_bk.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\project\uart\uart_dma.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\project\uart\uart_dma_bk.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\project\uart\uart_it.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\project\uart\uart_it_bk.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\project\uart\uart_baudrateRx.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\project\uart\uart_baudrateTx.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\project\uart\uart_printf_hal.ewp</path>
	</project>
	<batchBuild>
		<batchDefinition>
			<name>MM32L373</name>
			<member>
				<project>uart_polling_bk</project>
				<configuration>MM32L373</configuration>
			</member>
			<member>
				<project>uart_dma</project>
				<configuration>MM32L373</configuration>
			</member>
			<member>
				<project>uart_dma_bk</project>
				<configuration>MM32L373</configuration>
			</member>
			<member>
				<project>uart_it</project>
				<configuration>MM32L373</configuration>
			</member>
			<member>
				<project>uart_it_bk</project>
				<configuration>MM32L373</configuration>
			</member>
			<member>
				<project>uart_baudrateRx</project>
				<configuration>MM32L373</configuration>
			</member>
			<member>
				<project>uart_baudrateTx</project>
				<configuration>MM32L373</configuration>
			</member>
			<member>
				<project>uart_printf_hal</project>
				<configuration>MM32L373</configuration>
			</member>
		</batchDefinition>
		<batchDefinition>
			<name>MM32L073</name>
			<member>
				<project>uart_polling_bk</project>
				<configuration>MM32L073</configuration>
			</member>
			<member>
				<project>uart_dma</project>
				<configuration>MM32L073</configuration>
			</member>
			<member>
				<project>uart_dma_bk</project>
				<configuration>MM32L073</configuration>
			</member>
			<member>
				<project>uart_it</project>
				<configuration>MM32L073</configuration>
			</member>
			<member>
				<project>uart_it_bk</project>
				<configuration>MM32L073</configuration>
			</member>
			<member>
				<project>uart_baudrateRx</project>
				<configuration>MM32L073</configuration>
			</member>
			<member>
				<project>uart_baudrateTx</project>
				<configuration>MM32L073</configuration>
			</member>
			<member>
				<project>uart_printf_hal</project>
				<configuration>MM32L073</configuration>
			</member>
		</batchDefinition>
		<batchDefinition>
			<name>MM32SPIN27</name>
			<member>
				<project>uart_polling_bk</project>
				<configuration>MM32SPIN27</configuration>
			</member>
			<member>
				<project>uart_dma</project>
				<configuration>MM32SPIN27</configuration>
			</member>
			<member>
				<project>uart_it</project>
				<configuration>MM32SPIN27</configuration>
			</member>
			<member>
				<project>uart_baudrateRx</project>
				<configuration>MM32SPIN27</configuration>
			</member>
			<member>
				<project>uart_baudrateTx</project>
				<configuration>MM32SPIN27</configuration>
			</member>
			<member>
				<project>uart_printf_hal</project>
				<configuration>MM32SPIN27</configuration>
			</member>
		</batchDefinition>
	</batchBuild>
</workspace>
