<?xml version="1.0"?>
<workspace>
	<project>
		<path>$WS_DIR$\project\power\pwr_pvd_async.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\project\power\pwr_pvd_sync.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\project\power\pwr_sleep.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\project\power\pwr_standby.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\project\power\pwr_stop.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\project\power\pwr_iwdg_standby.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\project\power\pwr_rtc_standby.ewp</path>
	</project>
	<batchBuild>
		<batchDefinition>
			<name>MM32L373</name>
			<member>
				<project>pwr_pvd_async</project>
				<configuration>MM32L373</configuration>
			</member>
			<member>
				<project>pwr_pvd_sync</project>
				<configuration>MM32L373</configuration>
			</member>
			<member>
				<project>pwr_sleep</project>
				<configuration>MM32L373</configuration>
			</member>
			<member>
				<project>pwr_standby</project>
				<configuration>MM32L373</configuration>
			</member>
			<member>
				<project>pwr_stop</project>
				<configuration>MM32L373</configuration>
			</member>
			<member>
				<project>pwr_iwdg_standby</project>
				<configuration>MM32L373</configuration>
			</member>
			<member>
				<project>pwr_rtc_standby</project>
				<configuration>MM32L373</configuration>
			</member>
		</batchDefinition>
		<batchDefinition>
			<name>MM32L073</name>
			<member>
				<project>pwr_pvd_async</project>
				<configuration>MM32L073</configuration>
			</member>
			<member>
				<project>pwr_pvd_sync</project>
				<configuration>MM32L073</configuration>
			</member>
			<member>
				<project>pwr_sleep</project>
				<configuration>MM32L073</configuration>
			</member>
			<member>
				<project>pwr_standby</project>
				<configuration>MM32L073</configuration>
			</member>
			<member>
				<project>pwr_stop</project>
				<configuration>MM32L073</configuration>
			</member>
			<member>
				<project>pwr_iwdg_standby</project>
				<configuration>MM32L073</configuration>
			</member>
		</batchDefinition>
		<batchDefinition>
			<name>MM32SPIN27</name>
			<member>
				<project>pwr_pvd_async</project>
				<configuration>MM32SPIN27</configuration>
			</member>
			<member>
				<project>pwr_pvd_sync</project>
				<configuration>MM32SPIN27</configuration>
			</member>
			<member>
				<project>pwr_sleep</project>
				<configuration>MM32SPIN27</configuration>
			</member>
			<member>
				<project>pwr_standby</project>
				<configuration>MM32SPIN27</configuration>
			</member>
			<member>
				<project>pwr_stop</project>
				<configuration>MM32SPIN27</configuration>
			</member>
			<member>
				<project>pwr_iwdg_standby</project>
				<configuration>MM32SPIN27</configuration>
			</member>
		</batchDefinition>
	</batchBuild>
</workspace>
