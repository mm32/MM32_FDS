<?xml version="1.0"?>
<workspace>
	<project>
		<path>$WS_DIR$\project\i2c\i2c_dma.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\project\i2c\i2c_it.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\project\i2c\i2c_polling.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\project\i2c\i2c_search.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\project\i2c\i2c_slave_it.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\project\i2c\i2c_slave_polling.ewp</path>
	</project>
	<batchBuild>
		<batchDefinition>
			<name>MM32L373</name>
			<member>
				<project>i2c_dma</project>
				<configuration>MM32L373</configuration>
			</member>
			<member>
				<project>i2c_it</project>
				<configuration>MM32L373</configuration>
			</member>
			<member>
				<project>i2c_polling</project>
				<configuration>MM32L373</configuration>
			</member>
			<member>
				<project>i2c_search</project>
				<configuration>MM32L373</configuration>
			</member>
			<member>
				<project>i2c_slave_it</project>
				<configuration>MM32L373</configuration>
			</member>
			<member>
				<project>i2c_slave_polling</project>
				<configuration>MM32L373</configuration>
			</member>
		</batchDefinition>
		<batchDefinition>
			<name>MM32L073</name>
			<member>
				<project>i2c_dma</project>
				<configuration>MM32L073</configuration>
			</member>
			<member>
				<project>i2c_it</project>
				<configuration>MM32L073</configuration>
			</member>
			<member>
				<project>i2c_polling</project>
				<configuration>MM32L073</configuration>
			</member>
			<member>
				<project>i2c_search</project>
				<configuration>MM32L073</configuration>
			</member>
			<member>
				<project>i2c_slave_it</project>
				<configuration>MM32L073</configuration>
			</member>
			<member>
				<project>i2c_slave_polling</project>
				<configuration>MM32L073</configuration>
			</member>
		</batchDefinition>
		<batchDefinition>
			<name>MM32SPIN27</name>
			<member>
				<project>i2c_dma</project>
				<configuration>MM32SPIN27</configuration>
			</member>
			<member>
				<project>i2c_it</project>
				<configuration>MM32SPIN27</configuration>
			</member>
			<member>
				<project>i2c_polling</project>
				<configuration>MM32SPIN27</configuration>
			</member>
			<member>
				<project>i2c_search</project>
				<configuration>MM32SPIN27</configuration>
			</member>
			<member>
				<project>i2c_slave_it</project>
				<configuration>MM32SPIN27</configuration>
			</member>
			<member>
				<project>i2c_slave_polling</project>
				<configuration>MM32SPIN27</configuration>
			</member>
		</batchDefinition>
	</batchBuild>
</workspace>
