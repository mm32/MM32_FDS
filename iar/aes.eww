<?xml version="1.0"?>
<workspace>
	<project>
		<path>$WS_DIR$\project\aes\aes_ecb.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\project\aes\aes_cbc.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\project\aes\aes_ctr.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\project\aes\aes_cfb.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\project\aes\aes_ofb.ewp</path>
	</project>
	<batchBuild>
		<batchDefinition>
			<name>MM32L373</name>
			<member>
				<project>aes_ecb</project>
				<configuration>MM32L373</configuration>
			</member>
			<member>
				<project>aes_cbc</project>
				<configuration>MM32L373</configuration>
			</member>
			<member>
				<project>aes_ctr</project>
				<configuration>MM32L373</configuration>
			</member>
			<member>
				<project>aes_cfb</project>
				<configuration>MM32L373</configuration>
			</member>
			<member>
				<project>aes_ofb</project>
				<configuration>MM32L373</configuration>
			</member>
		</batchDefinition>
		<batchDefinition>
			<name>MM32L073</name>
			<member>
				<project>aes_ecb</project>
				<configuration>MM32L073</configuration>
			</member>
			<member>
				<project>aes_cbc</project>
				<configuration>MM32L073</configuration>
			</member>
			<member>
				<project>aes_ctr</project>
				<configuration>MM32L073</configuration>
			</member>
			<member>
				<project>aes_cfb</project>
				<configuration>MM32L073</configuration>
			</member>
			<member>
				<project>aes_ofb</project>
				<configuration>MM32L073</configuration>
			</member>
		</batchDefinition>
	</batchBuild>
</workspace>
